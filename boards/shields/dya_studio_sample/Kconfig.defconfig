## boards/shields/dya_studio_sample/Kconfig.shield
```kconfig
config SHIELD_DYA_STUDIO_SAMPLE
    def_bool $(shields_list_contains,dya_studio_sample)
```
